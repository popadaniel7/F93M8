# Keil uVision project APP2.uvprojx, settings and files
target APP2 (6190000::V6.19::ARMCLANG)
  device: TLE9893_2QKW62S Infineon
  pack: Infineon.TLE988x_9x_DFP.0.7.0
  cpu: IRAM(0x18000000,0x2000) IRAM2(0x18002000,0x5C00) IROM(0x11000000,0x6000) IROM2(0x12002000,0x3E000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-padded  -Wno-unused-parameter
  c include: ..\MultiCAN_first;.\app;..\MultiCAN_first;.\Can_iso_tp\can_iso_tp;.\Can_iso_tp\fifo;.\Can_iso_tp\mcu_lock;.\Uds_server;.\Drive
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x6000
  memory RVCT5: ROM 0x12020000 size 0xe000
  memory RVCT9: RAM 0x1800008 size 0x1ff8
  memory RVCT10: RAM 0x18002000 size 0x5c00
  scatter file: .\Objects\getting_started.sct
  group app
    ./app/: main.c main.h
  group can_iso_tp
    ./Can_iso_tp/can_iso_tp/: can_iso_tp.c
    ./Can_iso_tp/fifo/: FIFOQUEUE.c
    ./Can_iso_tp/mcu_lock/: mcu_lock.c
  group Uds_server
    ./Uds_server/: server.c UDS27_SA.c JumpToAPP.c TP_Config.c TP_Config.h
  group Drive
    ./Drive/: flash.c flash.h MultiCAN_handler.c MultiCAN_handler.h systick.c systick.h
software components: CMSIS:CORE 5.5.0, Device:ConfigWizard 0.0.0, Device:Startup 0.4.0, Device:TLELib:ADC1 0.4.9, Device:TLELib:ADC2 0.5.7, Device:TLELib:BDRV 0.8.2, Device:TLELib:BOOTROM 0.3.1, Device:TLELib:CANCONTR 0.3.3, Device:TLELib:CANTRX 0.3.4, Device:TLELib:CCU7 0.4.0, Device:TLELib:CSACSC 0.2.8, Device:TLELib:DMA 0.3.2, Device:TLELib:GPIO 0.2.6, Device:TLELib:GPT12 0.6.2, Device:TLELib:INT 0.3.1, Device:TLELib:ISR 0.5.0, Device:TLELib:MON 0.3.4, Device:TLELib:PMU 0.5.7, Device:TLELib:SCU 0.5.4, Device:TLELib:SDADC 0.4.0, Device:TLELib:SSC 0.3.8, Device:TLELib:TIMER2X 0.5.0, Device:TLELib:UART 0.5.9
